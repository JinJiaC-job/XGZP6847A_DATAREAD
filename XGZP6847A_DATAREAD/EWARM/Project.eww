<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XGZP6847A_DATAREAD.ewp</path>
  </project>
  <batchBuild />
</workspace>
